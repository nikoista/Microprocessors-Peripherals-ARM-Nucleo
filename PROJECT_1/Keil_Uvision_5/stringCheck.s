			GLOBAL stringCheck
			AREA |.PalindromicString| , CODE , READONLY
			EXPORT stringCheck
stringCheck												;ROUTINE-FUNCTION POU DEIXNEI AN TO STRING/
														;/POU TOU PERASAME SAN ORISMA EINAI PALINDROMIKO H OXI
			ADDS r6 , r1 , r0;							;PERNAW TO ADRESS TOU R0 DHLADH THN ARXH + TO MEGETHOS TOY STRING GIA NA PAW STO TELOS
			ADDS r1 , r1 , #1;							;AUXANW TO MEGETHOS TOU STRING +1 GT TO PERASA SAN -1 STO ORISMA THS SUNARTHSHS
			LDRB r9 , [r0] ;							;PERNAW THN TIMH POU EXEI MESA TO R0 ADRESS STO R9
			LDRB r11 , [r6] ;							;PERNAW THN TIMH POU EXEI MESA TO R6 ADRESS STO R11
			CMP r9 , #'\0' ;							;ELENXW AN EVALA SAN STRING TO '\0' APO THN ARXH
			CMP r11 , #'\0' ; 							;ELENXW AN EVALA SAN STRING TO '\0' APO TO TELOS
			BNE Loop ;									;AN OXI TOTE PHGAINE STO LOOP
			SUBS r0 , r0 , r0 ;							;AN NAI TOTE MHDENISE TO ADRESS TOU R0 
			ADD	 r0 , #'Y' ;							;PERASE MESA STO R0 THN TIMH 'Y'
			SUBS r4, r4 , r4 ;							;VALE STO R4 THN TIMH 0 OMWS TO R4 EXEI KAI THN TIMH TOU LENGTH OPOTE TO KANW 0
			ADD r4 , #1;								;VAZW THN TIMH 1 STO R4 DIOTI NAI TO STRING EINAI PALINDROMIKO KAI OLA PHGAN KALA
			BX lr;										;EPISTREFW ME JUMP AND REGISTER STO PROGRAMMA C ME ALLAGMENA TA REGISTERS R0 KAI R1/
Loop													;/TA R0 KAI R1 EINAI TA DUO REGISTERS POU ANAKTW STO C PROGRAMMA KAI EXOUN TA RETURNS APO THN ROUTINA 
			LDRB r9 , [r0] ;							;PERNAW THN TIMH POU EXEI MESA TO R0 ADRESS STO R9
			LDRB r11 , [r6] ;							;PERNAW THN TIMH POU EXEI MESA TO R0 ADRESS STO R11
			CMP r9 , r11 ;								;SUGRINW AN TA R9 KAI R11 POU EXOUN THN ARXH KAI TO TELOS TOU STRING AN EINAI IDIA
			BEQ Palindromic;							;AN NAI PHGAINE STO SHMEIO Palindromic
			SUBS r0 , r0 , r0 ;							;AN OXI TOTE TOTE MHDENISE TO ADRESS TOU R0 
			ADD	 r0 , #'N' ;							;PERASE MESA STO R0 THN TIMH 'N'
			SUBS r4 , r4 , r4 ;							;VALE STO R4 THN TIMH 0 OMWS TO R4 EXEI KAI THN TIMH TOU LENGTH OPOTE TO KANW 0
			BX lr;										;EPISTREFW ME JUMP AND REGISTER STO PROGRAMMA C OPWS PANW
Palindromic												;EDW EINAI TO STRING PALINDROMIKO OPOTE KANW TIS APARAITITES ALLAGES
			ADD r0 ,  #1 ;								;AUXANO TO POU DEIXNEI O POINTER R0 +1 THESH MNHMHS OPOTE 1 BYTE AFOU EXW STRING
			SUB r6 ,  #1 ; 								;AUXANO TO POU DEIXNEI O POINTER R6 +1 THESH MNHMHS OPOTE 1 BYTE AFOU EXW STRING
			ADDS r8 , r8 , #1 ;							;AUXANO THN TIMH TOU REGISTER R8 GIA NA XERW POTE TELEIWNEI TO STRING
			CMP r8 , r1 ;								;ELENXW AN TO R8 EINAI IDIO ME TO R1 POU EXEI SAN TIMH TO MEGETHOS TOU STRING
			BNE Loop ;									;AN OXI SUNEXISE NA ELENXEIS TO STRING MEXRI NA FTASOUME STO TELOS
			SUBS r0 , r0 , r0 ;							;AN NAI TOTE TOTE MHDENISE TO ADRESS TOU R0 
			ADD	 r0 , #'Y' ;							;PERASE MESA STO R0 THN TIMH 'Y'
			SUBS r4 , r4, r4;							;VALE STO R4 THN TIMH 0 OMWS TO R4 EXEI KAI THN TIMH TOU LENGTH OPOTE TO KANW 0
			ADD r4 , #1;								;VAZW THN TIMH 1 STO R4 DIOTI NAI TO STRING EINAI PALINDROMIKO KAI OLA PHGAN KALA
			BX lr;										;EPISTREFW ME JUMP AND REGISTER STO PROGRAMMA C OPWS PANW
			END											;EDW TELEIWNEI TO PROGRAMMA ASSEMBLY