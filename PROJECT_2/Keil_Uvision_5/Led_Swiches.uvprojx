# Keil uVision project Led_Swiches.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Led_Swiches
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\drivers
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group src
    ./src/: main.c delay.c delay.h leds.c leds.h
  group drivers
    ./drivers/: gpio.c gpio.h platform.h
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.6.3
